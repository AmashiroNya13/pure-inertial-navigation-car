# Keil uVision project seekfree.uvproj, settings and files
target AI8051U_32bit (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  asm include: ..\..\libraries\zf_common
  link misc: REMOVEUNUSED,NOOVERLAY
  group zf_common
    ../../libraries/zf_common/: ai8051u_32bit.h ai8051u_isr.asm zf_common_headfile.h zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_function.c zf_common_function.h zf_common_typedef.c zf_common_typedef.h zf_common_interrupt.c zf_common_interrupt.h START251.A51
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_delay.c zf_driver_delay.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_uart.c zf_driver_uart.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_timer.c zf_driver_timer.h
  group user
    ../user/: isr.c isr.h main.c
  group doc
    ../../libraries/doc/: version.txt
  group bldc
    ../../bldc/: bldc_version.txt battery.c battery.h bldc_config.h comparator.c comparator.h motor_control.c motor_control.h pit_timer.c pit_timer.h pwm_out.c pwm_out.h signal_input.c signal_input.h sine_control.c sine_control.h
